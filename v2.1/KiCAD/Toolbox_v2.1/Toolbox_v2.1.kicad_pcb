# Repository StudioKAT/Toolbox (continued)

## KiCad design v2.1/KiCAD/Toolbox_v2.1/Toolbox_v2.1.kicad_pcb (continued)

Parts:
D23: LED_Dual_Bidirectional; LED_D3.0mm
J35: OUT_+10V; AudioJack_PJ301M-12
J36: IN_±5V; AudioJack_PJ301M-12
J37: IN_+10V; AudioJack_PJ301M-12
J38: OUT_±5V; AudioJack_PJ301M-12
R106, R107, R110, R111, R112, R113, R114, R115, R116, R118: 100K; R_0402_1005Metric; LCSC C25741
R108, R117: 100R; R_0402_1005Metric; LCSC C25076
R109: 1K; R_0402_1005Metric; LCSC C11702
U7, U8, U12: TL074CDR; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C12594

Connections:
GND: J35.S, J36.S, J36.TN, J37.S, J38.S, R109.1, U7.5 (+), U8.10 (+), U12.10 (+), U12.12 (+); also elsewhere on the board
unnamed: D23.2 (AK), U8.14
unnamed: D23.1 (KA), R109.2, U8.13 (-)
unnamed: J35.T, R108.2
unnamed: J36.T, R110.1
unnamed: J37.T, R115.1
unnamed: J37.TN, R107.2, R108.1, U7.7
unnamed: J38.T, R117.2
unnamed: R106.2, R111.1, U8.8
unnamed: R113.2, R116.1, U12.14
unnamed: R107.1, R111.2, R112.2, U7.6 (-)
unnamed: R106.1, R110.2, U8.9 (-)
unnamed: R114.2, R117.1, U8.12 (+), U12.8
unnamed: R114.1, R116.2, R118.2, U12.9 (-)
unnamed: R113.1, R115.2, U12.13 (-)
VREF_+5: R118.1; also elsewhere on the board
VREF_-5: R112.1; also elsewhere on the board

Notes on the sheet:
0~+10V
-10V~0V
±5V
+:Green -:Red
∓5V

Parts:
D10: LED_Dual_Bidirectional; LED_D3.0mm
D11, D12: 1N4148WS; D_SOD-323; LCSC C2128
J22: Kinks_IN; AudioJack_PJ301M-12
J23: Kinks_OUT_INV; AudioJack_PJ301M-12
J24: Kinks_OUT_HW; AudioJack_PJ301M-12
J25: Kinks_OUT_FW; AudioJack_PJ301M-12
R66, R67, R71, R72, R77, R78: 200K; R_0402_1005Metric; LCSC C25764
R68, R74, R79: 100R; R_0402_1005Metric; LCSC C25076
R69: 1K; R_0402_1005Metric; LCSC C11702
R70, R73, R75, R76: 100K; R_0402_1005Metric; LCSC C25741
U6, U10: TL074CDR; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C12594

Connections:
GND: J22.S, J22.TN, J23.S, J24.S, J25.S, R69.1, U10.3 (+), U10.5 (+), U10.10 (+), U10.12 (+); also elsewhere on the board
unnamed: D10.2 (AK), U6.1
unnamed: D10.1 (KA), R69.2, U6.2 (-)
unnamed: D11.2 (A), D12.1 (K), U10.7
unnamed: D11.1 (K), R70.1, R72.2, U10.6 (-)
unnamed: D12.2 (A), R70.2, R73.1, R75.1, R76.1
unnamed: J23.T, R68.2
unnamed: J24.T, R74.2
unnamed: J25.T, R79.2
unnamed: R66.2, R68.1, U10.1
unnamed: R71.2, R74.1, U10.8
unnamed: R77.2, R79.1, U10.14
unnamed: J22.T, R67.1, R72.1, R78.1, U6.3 (+)
unnamed: R66.1, R67.2, U10.2 (-)
unnamed: R71.1, R73.2, U10.9 (-)
unnamed: R75.2, R76.2, R77.1, R78.2, U10.13 (-)

Notes on the sheet:
+:Green -:Red

Schematic: Voltage_Doubler.kicad_sch, Voltage Doubler

Parts:
C46: 10p; C_0402_1005Metric; LCSC C32949
D24: LED_Dual_Bidirectional; LED_D3.0mm
J39: IN; AudioJack_PJ301M-12
J40: OUT_x1.25; AudioJack_PJ301M-12
J41: OUT_x1.6; AudioJack_PJ301M-12
J42: OUT_x2; AudioJack_PJ301M-12
R119, R121, R127: 100K; R_0402_1005Metric; LCSC C25741
R120: 150K; R_0402_1005Metric; LCSC C25755
R122, R124: 120K; R_0402_1005Metric; LCSC C25750
R123, R126, R129: 100R; R_0402_1005Metric; LCSC C25076
R125: 75K; R_0402_1005Metric; LCSC C25798
R128: 49.9K; R_0402_1005Metric; LCSC C25897
R130: 1K; R_0402_1005Metric; LCSC C11702
U4, U8, U12: TL074CDR; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C12594

Connections:
GND: J39.S, J39.TN, J40.S, J41.S, J42.S, R130.1, U8.3 (+), U8.5 (+), U12.3 (+), U12.5 (+); also elsewhere on the board
unnamed: C46.2, R119.2, R122.1, R125.1, R128.1, U8.1
unnamed: D24.2 (AK), U4.7
unnamed: D24.1 (KA), R130.2, U4.6 (-)
unnamed: J40.T, R123.2
unnamed: J41.T, R126.2
unnamed: J42.T, R129.2
unnamed: R120.2, R123.1, U8.7
unnamed: R124.2, R126.1, U12.1
unnamed: R127.2, R129.1, U12.7
unnamed: J39.T, R121.1, U4.5 (+)
unnamed: C46.1, R119.1, R121.2, U8.2 (-)
unnamed: R120.1, R122.2, U8.6 (-)
unnamed: R124.1, R125.2, U12.2 (-)
unnamed: R127.1, R128.2, U12.6 (-)

Notes on the sheet:
8V to 10V
5V to 10V
+:Green -:Red
5V to 8V

Board: 2 copper layers, 170.4 x 128.5 mm, 340 parts (210 on the bottom side), 181 nets.

## KiCad design v1.0/KiCAD/Toolbox_v1.0/Toolbox_v1.0.kicad_pcb

Parts:
H1: Panel; Panel_16HP
H2, H3, H4, H5: PH_Pot; PH_RK097_15mmKnob_BI_UNI
H6, H7, H8, H9, H10, H11, H12, H13: PH_SW; PH_ToggleSwitch_5.1mm
H14, H15, H16, H17, H26, H27, H28, H29, H30, H31, H32, H33: PH_LED; PH_LED_3.0mm
H18, H19, H20, H21, H22, H23, H24, H25, H34, H35, H36, H37, H38, H39, H40, H41, H42, H43, H44, H45, H46, H47, H48, H49, H50, H51, H52, H53, H54, H55, H56, H57, H58, H59, H60, H61, H62, H63, H64, H65: PH_Audio; PH_AudioJack_3.5mm

Parts:
C35, C36, C37, C38: 22p; C_0402_1005Metric; LCSC C1555
D3, D4, D5, D6: LED_Dual_Bidirectional; LED_D3.0mm
J2: OUT_1; AudioJack_PJ301M-12
J3: IN_1; AudioJack_PJ301M-12
J4: OUT_2; AudioJack_PJ301M-12
J5: IN_2; AudioJack_PJ301M-12
J6: OUT_3; AudioJack_PJ301M-12
J7: IN_3; AudioJack_PJ301M-12
J8: OUT_4; AudioJack_PJ301M-12
J9: IN_4; AudioJack_PJ301M-12
R10, R11, R12, R13, R16, R17, R18, R19, R20, R21, R22, R23, R26, R27, R28, R29, R30, R31, R32, R33, R36, R37, R38, R39, R40, R41, R42, R43, R46: 100K; R_0402_1005Metric; LCSC C25741
R14, R15, R24, R25, R34, R35, R44, R45: 1K; R_0402_1005Metric; LCSC C11702
RV1, RV2, RV3, RV4: B10K; Potentiometer_RV09
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8: SW_SPDT; ToggleSwitch_2MS1-T2-B4-M2-Q-E-S
U1, U2, U3, U4: TL074; TSSOP-14_4.4x5mm_P0.65mm; LCSC C4370424

Connections:
GND: J2.S, J3.S, J4.S, J5.S, J6.S, J7.S, J8.S, J9.S, R15.1, R25.1, R35.1, R45.1, SW2.1 (A), SW4.1 (A), SW6.1 (A), SW8.1 (A), U1.5 (+), U1.10 (+), U1.12 (+), U2.5 (+), U2.10 (+), U2.12 (+), U3.5 (+), U3.10 (+), U3.12 (+), U4.10 (+), U4.12 (+); also elsewhere on the board
unnamed: C35.2, R14.1, U1.8
unnamed: C36.2, R24.1, U2.8
unnamed: C37.2, R34.1, U3.8
unnamed: C38.2, R44.1, U4.8
unnamed: D3.2 (AK), U1.1
unnamed: D3.1 (KA), R15.2, U1.2 (-)
unnamed: D4.2 (AK), U2.1
unnamed: D4.1 (KA), R25.2, U2.2 (-)
unnamed: D5.2 (AK), U3.1
unnamed: D5.1 (KA), R35.2, U3.2 (-)
unnamed: D6.2 (AK), U4.1
unnamed: D6.1 (KA), R45.2, U4.2 (-)
unnamed: J2.TN, R18.1
unnamed: J3.T, R16.1
unnamed: J4.TN, R28.1
unnamed: J5.T, R26.1
unnamed: J6.TN, R38.1
unnamed: J7.T, R36.1
unnamed: J9.T, R46.1
unnamed: R12.2, R13.1, U1.14
unnamed: R16.2, RV1.2
unnamed: R17.2, R19.1, U1.7
unnamed: R22.2, R23.1, U2.14
unnamed: R26.2, RV2.2
unnamed: R27.2, R29.1, U2.7
unnamed: R32.2, R33.1, U3.14
unnamed: R36.2, RV3.2
unnamed: R37.2, R39.1, U3.7
unnamed: R42.2, R43.1, U4.14
unnamed: R46.2, RV4.2
unnamed: J3.TN, SW1.2 (B)
unnamed: R11.2, SW1.3 (C)
unnamed: RV1.1, SW2.2 (B)
unnamed: C35.1, R10.1, R13.2, SW2.3 (C), U1.9 (-)
unnamed: J5.TN, SW3.2 (B)
unnamed: R21.2, SW3.3 (C)
unnamed: RV2.1, SW4.2 (B)
unnamed: C36.1, R19.2, R20.1, R23.2, SW4.3 (C), U2.9 (-)
unnamed: J7.TN, SW5.2 (B)
unnamed: R31.2, SW5.3 (C)
unnamed: RV3.1, SW6.2 (B)
unnamed: C37.1, R29.2, R30.1, R33.2, SW6.3 (C), U3.9 (-)
unnamed: J9.TN, SW7.2 (B)
unnamed: R41.2, SW7.3 (C)
unnamed: RV4.1, SW8.2 (B)
unnamed: C38.1, R39.2, R40.1, R43.2, SW8.3 (C), U4.9 (-)
unnamed: J2.T, R10.2, R14.2, U1.3 (+)
unnamed: R17.1, R18.2, U1.6 (-)
unnamed: R12.1, RV1.3, U1.13 (-)
unnamed: J4.T, R20.2, R24.2, U2.3 (+)
unnamed: R27.1, R28.2, U2.6 (-)
unnamed: R22.1, RV2.3, U2.13 (-)
unnamed: J6.T, R30.2, R34.2, U3.3 (+)
unnamed: R37.1, R38.2, U3.6 (-)
unnamed: R32.1, RV3.3, U3.13 (-)
unnamed: J8.T, R40.2, R44.2, U4.3 (+)
unnamed: R42.1, RV4.3, U4.13 (-)
VREF_+10: R11.1, R21.1, R31.1, R41.1, SW1.1 (A), SW3.1 (A), SW5.1 (A), SW7.1 (A); also elsewhere on the board

Notes on the sheet:
+:Green -:Red
+:Green -:Red 1→2(Anode→Cathode)順方向で赤点灯なので +で緑にしたい場合、足が短いカソード側をオペアンプ1番ピンに繋ぐ

Parts:
C1, C2: 22uF; C_0805_2012Metric; LCSC C45783
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C22, C23, C24, C25, C27, C28, C29, C30, C31, C32, C33, C34: 100nF; C_0402_1005Metric; LCSC C1525
C21, C26: 10u; CP_EIA-3216-18_Kemet-A; LCSC C7171
D1, D2: 1N5819WS; D_SOD-323; LCSC C64886
J1: POWER; PinHeader_2x05_2.54mm_Europower
R1, R4, R9: 1K; R_0402_1005Metric; LCSC C11702
R2: 100K; R_0402_1005Metric; LCSC C25741
R3: 33K; R_0402_1005Metric; LCSC C25779
R5, R6, R7, R8: 10K; R_0402_1005Metric; LCSC C25744
TP1: +10V_TP; TestPoint_Pad_1.0x1.0mm
TP2: +5V_TP; TestPoint_Pad_1.0x1.0mm
TP3: -5V_TP; TestPoint_Pad_1.0x1.0mm
U1, U2, U3, U4, U6, U9, U10, U11, U12: TL074; TSSOP-14_4.4x5mm_P0.65mm; LCSC C4370424
U5, U7, U8: TL074; TSSOP-14_4.4x5mm_P0.65mm
U13, U14, U15: CJ431; SOT-23; LCSC C3113

Connections:
+12V: C1.1, C3.1, C4.1, C5.1, C6.1, C11.1, C12.1, C13.1, C14.1, C19.1, C20.1, C21.1, C22.1, C23.1, D1.1 (K), R1.1, R4.1, U1.4 (V+), U2.4 (V+), U3.4 (V+), U4.4 (V+), U5.4 (V+), U6.4 (V+), U7.4 (V+), U8.4 (V+), U9.4 (V+), U10.4 (V+), U11.4 (V+), U12.4 (V+); also elsewhere on the board
-12V: C2.2, C7.2, C8.2, C9.2, C10.2, C15.2, C16.2, C17.2, C18.2, C24.2, C25.2, C26.2, C27.2, C28.2, D2.2 (A), R9.1, U1.11 (V-), U2.11 (V-), U3.11 (V-), U4.11 (V-), U5.11 (V-), U6.11 (V-), U7.11 (V-), U8.11 (V-), U9.11 (V-), U10.11 (V-), U11.11 (V-), U12.11 (V-); also elsewhere on the board
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.1, C10.1, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, C17.1, C18.1, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.1, C26.1, C27.1, C28.1, C29.2, C30.2, C31.2, C32.2, C33.1, C34.1, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, R3.2, R6.2, R7.1, U13.3 (A), U14.3 (A), U15.2 (K); also elsewhere on the board
unnamed: D1.2 (A), J1.1, J1.2
unnamed: D2.1 (K), J1.9, J1.10
unnamed: R2.2, R3.1, U13.1 (REF)
unnamed: R5.2, R6.1, U14.1 (REF)
unnamed: R7.2, R8.1, U15.1 (REF)
VREF_+5: C31.1, C32.1, R4.2, R5.1, TP2.1, U14.2 (K); also elsewhere on the board
VREF_+10: C29.1, C30.1, R1.2, R2.1, TP1.1, U13.2 (K); also elsewhere on the board
VREF_-5: C33.2, C34.2, R8.2, R9.2, TP3.1, U15.3 (A); also elsewhere on the board

Parts:
C41: 100nF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C42, C43: 10u; CP_EIA-3216-18_Kemet-A; LCSC C7171
C44: 10n; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C45: 100p; C_0402_1005Metric; LCSC C1546
D20, D22: 1N4148WS; D_SOD-323; LCSC C2128
D21: LED_Dual_Bidirectional; LED_D3.0mm
J30: Kinks_OUT_Noise; AudioJack_PJ301M-12
J31: Kinks_OUT_S&H; AudioJack_PJ301M-12
J32: Kinks_S&H_IN; AudioJack_PJ301M-12
J33: Kinks_S&H_TRIG; AudioJack_PJ301M-12
Q1, Q2: MMBT3904; SOT-23; LCSC C20526
Q3: MMBFJ310; SOT-23
R91: 470K; R_0402_1005Metric; LCSC C25790
R92: 4.7K; R_0402_1005Metric; LCSC C25900
R93: 240K; R_0603_1608Metric; LCSC C4197
R94, R102, R103: 100K; R_0402_1005Metric; LCSC C25741
R95, R96: 100R; R_0402_1005Metric; LCSC C25076
R97, R98, R99: 1M; R_0402_1005Metric; LCSC C26083
R100: 1K; R_0402_1005Metric; LCSC C11702
R101, R104: 10K; R_0402_1005Metric; LCSC C25744
U7, U11: TL074; TSSOP-14_4.4x5mm_P0.65mm; LCSC C4370424

Connections:
+12V: R91.1, R92.1, R99.1; also elsewhere on the board
GND: C43.2, C44.2, D22.2 (A), J30.S, J31.S, J32.S, J33.S, J33.TN, Q2.2 (E), R97.2, R100.1, R102.2, R103.2, R104.2, U11.10 (+); also elsewhere on the board
unnamed: C41.2, R94.1
unnamed: C42.2, C43.1
unnamed: C45.1, J33.T, R102.1
unnamed: D20.2 (A), Q3.3 (G), R98.2
unnamed: D20.1 (K), U11.14
unnamed: D21.2 (AK), U7.1
unnamed: D21.1 (KA), R100.2, U7.2 (-)
unnamed: C45.2, D22.1 (K), R101.1
unnamed: J30.T, J32.TN, R95.2
unnamed: J31.T, R96.2
unnamed: Q1.1 (B), Q2.1 (B)
unnamed: C42.1, Q1.2 (E), R91.2
unnamed: C41.1, Q2.3 (C), R92.2
unnamed: Q3.1 (D), R98.1, U11.1, U11.2 (-)
unnamed: C44.1, Q3.2 (S), U11.5 (+)
unnamed: R93.2, R95.1, U11.8
unnamed: J32.T, R97.1, U11.3 (+)
unnamed: R96.1, U7.3 (+), U11.6 (-), U11.7
unnamed: R93.1, R94.2, U11.9 (-)
unnamed: R101.2, R103.1, U11.12 (+)
unnamed: R99.2, R104.1, U11.13 (-)

Notes on the sheet:
- 22pF並列 -
ノイズ周りだけオペアンプ分けたほうがいいかも rev2で対応予定
Flilm cap
Tantalum 5uF
+:Green -:Red

Parts:
D13, D14, D15, D16, D17, D18: 1N4148WS; D_SOD-323; LCSC C2128
D19: LED_Dual_Bidirectional; LED_D3.0mm
J26: Kinks_OUT_MAX; AudioJack_PJ301M-12
J27: Kinks_IN_A; AudioJack_PJ301M-12
J28: Kinks_IN_B; AudioJack_PJ301M-12
J29: Kinks_OUT_MIN; AudioJack_PJ301M-12
R82, R84, R85, R87: 220K; R_0402_1005Metric; LCSC C25767
R83, R86: 100R; R_0402_1005Metric; LCSC C25076
R88, R89: 1M; R_0402_1005Metric; LCSC C26083
R90: 1K; R_0402_1005Metric; LCSC C11702
U6, U7: TL074; TSSOP-14_4.4x5mm_P0.65mm; LCSC C4370424

Connections:
+12V: R85.1, R87.2; also elsewhere on the board
-12V: R82.1, R84.2; also elsewhere on the board
GND: J26.S, J27.S, J27.TN, J28.S, J28.TN, J29.S, R90.1; also elsewhere on the board
unnamed: D13.2 (A), R83.1, U7.8
unnamed: D13.1 (K), R82.2, U7.9 (-)
unnamed: D14.2 (A), D17.1 (K), J27.T, R88.1
unnamed: D14.1 (K), D15.1 (K), R84.1, U7.10 (+)
unnamed: D15.2 (A), D18.1 (K), J28.T, R89.1
unnamed: D16.2 (A), R85.2, U6.6 (-)
unnamed: D16.1 (K), R86.1, U6.7
unnamed: D17.2 (A), D18.2 (A), R87.1, U6.5 (+)
unnamed: D19.2 (AK), U7.14
unnamed: D19.1 (KA), R90.2, U7.13 (-)
unnamed: J26.T, R83.2
unnamed: J29.T, R86.2
unnamed: R88.2, R89.2, U7.12 (+)

Notes on the sheet:
+:Green -:Red
