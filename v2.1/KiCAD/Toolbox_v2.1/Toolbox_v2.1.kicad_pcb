# Repository StudioKAT/Toolbox

File README.md:

# Toolbox

## 概要 / Overview

**Toolbox** は、16HPサイズの中にモジュラーシンセに必要な多彩なユーティリティ機能を凝縮した多機能ツールボックスモジュールです。  
Mutable Instruments の「Shades」「Links」「Kinks」をベースにしつつ、独自の機能追加を行いました。

主な機能：
- オーディオ/CVミキサー（加算・減算）
- CVへのオフセット追加(5V/10V)・極性反転
- 1:3 バッファード・マルチプル
- 2:2 ユニティミキサー
- 3:1 アベレージミキサー（各チャンネルのゲイン = 1/3）
- SIGNセクション：インバーター / 半波整流 / 全波整流
- LOGICセクション：アナログOR / アナログAND
- S&Hセクション：サンプル＆ホールド / ホワイトノイズ出力
- OFFSET：±5V ↔ 0〜10Vの変換（5Vオフセット）
- AMP：CVやオーディオ信号の増幅  
  - 8V → 10V（x1.25）  
  - 5V → 8V（x1.6）  
  - 5V → 10V（x2）

**Toolbox** is a multifunction utility module that packs a wide range of essential modular synthesis tools into a compact 16HP format.  
It is based on Mutable Instruments' *Shades*, *Links*, and *Kinks*, with several added original features.

Key features include:
- Audio/CV mixer (for both addition and subtraction)
- Offset(5V/10V) and polarity inversion for CV signals
- 1:3 buffered multiple
- 2:2 unity mixer
- 3:1 averaging mixer (each channel gain = 1/3)
- SIGN section: inverter / half-wave rectifier / full-wave rectifier
- LOGIC section: analog OR / analog AND gates
- S&H section: sample & hold circuit / white noise output
- OFFSET: 5V offset converter for ±5V ↔ 0–10V signal conversion
- AMP: amplification of CV and audio signals  
  - 8V → 10V (x1.25)  
  - 5V → 8V (x1.6)  
  - 5V → 10V (x2)

## 仕様 / Spec
- Format: Eurorack
- Function: Multi tools
- Current needs: +12V: 130mA, -12V: 130mA
- Width: 16 HP
- Depth: 25mm (including power connector)

## 販売 / Sales

StudioKATオフィシャルショップで販売しています。(日本国内限定)  
https://www.studiokat.jp/items/106541624

## ライセンス / License

この作品は [Creative Commons 表示 - 継承 4.0 国際 (CC BY-SA 4.0)](https://creativecommons.org/licenses/by-sa/4.0/deed.ja) の下でライセンスされています。  
This work is licensed under the [Creative Commons Attribution-ShareAlike 4.0 International License](https://creativecommons.org/licenses/by-sa/4.0/).

## クレジット / Credits

- Designed by : StudioKAT
- Website : https://www.studiokat.jp/
- GitHub : https://github.com/StudioKAT
- X(Twitter) : https://x.com/StudioKAT_synth
- Instagram : https://www.instagram.com/studiokat_modular/

## 更新履歴 / Changelog

- `2025-05-28` v1.0 Released 
- `2025-07-31` v2.1 Released  
オペアンプ変更、ホワイトノイズ切り替え機能追加、リファレンス電源回路変更

## KiCad design v2.1/KiCAD/Toolbox_v2.1/Toolbox_v2.1.kicad_pcb

Parts:
H1: Panel; Panel_16HP
H2, H3, H4, H5: PH_Pot; PH_RK097_15mmKnob_BI_UNI_Pad
H6, H7, H8, H9, H10, H11, H12, H13: PH_SW; PH_ToggleSwitch_5.1mm_Pad
H14, H15, H16, H17, H26, H27, H28, H29, H30, H31, H32, H33: PH_LED; PH_LED_3.0mm_Pad
H18, H19, H20, H21, H22, H23, H24, H25, H34, H35, H36, H37, H38, H39, H40, H41, H42, H43, H44, H45, H46, H47, H48, H49, H50, H51, H52, H53, H54, H55, H56, H57, H58, H59, H60, H61, H62, H63, H64, H65: PH_Audio; PH_AudioJack_3.5mm_Pad

Connections:
GND1: H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), H5.1 (1_1), H6.1 (1_1), H7.1 (1_1), H8.1 (1_1), H9.1 (1_1), H10.1 (1_1), H11.1 (1_1), H12.1 (1_1), H13.1 (1_1), H14.1 (1_1), H15.1 (1_1), H16.1 (1_1), H17.1 (1_1), H18.1 (1_1), H19.1 (1_1), H20.1 (1_1), H21.1 (1_1), H22.1 (1_1), H23.1 (1_1), H24.1 (1_1), H25.1 (1_1), H26.1 (1_1), H27.1 (1_1), H28.1 (1_1), H29.1 (1_1), H30.1 (1_1), H31.1 (1_1), H32.1 (1_1), H33.1 (1_1), H34.1 (1_1), H35.1 (1_1), H36.1 (1_1), H37.1 (1_1), H38.1 (1_1), H39.1 (1_1), H40.1 (1_1), H41.1 (1_1), H42.1 (1_1), H43.1 (1_1), H44.1 (1_1), H45.1 (1_1), H46.1 (1_1), H47.1 (1_1), H48.1 (1_1), H49.1 (1_1), H50.1 (1_1), H51.1 (1_1), H52.1 (1_1), H53.1 (1_1), H54.1 (1_1), H55.1 (1_1), H56.1 (1_1), H57.1 (1_1), H58.1 (1_1), H59.1 (1_1), H60.1 (1_1), H61.1 (1_1), H62.1 (1_1), H63.1 (1_1), H64.1 (1_1), H65.1 (1_1)

Parts:
C33, C34, C35, C36: 22p; C_0402_1005Metric; LCSC C1555
D3, D4, D5, D6: LED_Dual_Bidirectional; LED_D3.0mm
J2: OUT_1; AudioJack_PJ301M-12
J3: IN_1; AudioJack_PJ301M-12
J4: OUT_2; AudioJack_PJ301M-12
J5: IN_2; AudioJack_PJ301M-12
J6: OUT_3; AudioJack_PJ301M-12
J7: IN_3; AudioJack_PJ301M-12
J8: OUT_4; AudioJack_PJ301M-12
J9: IN_4; AudioJack_PJ301M-12
R8, R9, R10, R11, R14, R15, R16, R17, R18, R19, R20, R21, R24, R25, R26, R27, R28, R29, R30, R31, R34, R35, R36, R37, R38, R39, R40, R41, R44: 100K; R_0402_1005Metric; LCSC C25741
R12, R13, R22, R23, R32, R33, R42, R43: 1K; R_0402_1005Metric; LCSC C11702
RV1, RV2, RV3, RV4: B10K; Potentiometer_RV09
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8: SW_SPDT; ToggleSwitch_2MS1-T2-B4-M2-Q-E-S
U1, U2, U3, U4: TL074CDR; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C12594

Connections:
GND: J2.S, J3.S, J4.S, J5.S, J6.S, J7.S, J8.S, J9.S, R13.1, R23.1, R33.1, R43.1, SW2.1 (A), SW4.1 (A), SW6.1 (A), SW8.1 (A), U1.5 (+), U1.10 (+), U1.12 (+), U2.5 (+), U2.10 (+), U2.12 (+), U3.5 (+), U3.10 (+), U3.12 (+), U4.10 (+), U4.12 (+); also elsewhere on the board
unnamed: C33.2, R12.1, U1.8
unnamed: C34.2, R22.1, U2.8
unnamed: C35.2, R32.1, U3.8
unnamed: C36.2, R42.1, U4.8
unnamed: D3.2 (AK), U1.1
unnamed: D3.1 (KA), R13.2, U1.2 (-)
unnamed: D4.2 (AK), U2.1
unnamed: D4.1 (KA), R23.2, U2.2 (-)
unnamed: D5.2 (AK), U3.1
unnamed: D5.1 (KA), R33.2, U3.2 (-)
unnamed: D6.2 (AK), U4.1
unnamed: D6.1 (KA), R43.2, U4.2 (-)
unnamed: J2.TN, R16.1
unnamed: J3.T, R14.1
unnamed: J4.TN, R26.1
unnamed: J5.T, R24.1
unnamed: J6.TN, R36.1
unnamed: J7.T, R34.1
unnamed: J9.T, R44.1
unnamed: R10.2, R11.1, U1.14
unnamed: R14.2, RV1.2
unnamed: R15.2, R17.1, U1.7
unnamed: R20.2, R21.1, U2.14
unnamed: R24.2, RV2.2
unnamed: R25.2, R27.1, U2.7
unnamed: R30.2, R31.1, U3.14
unnamed: R34.2, RV3.2
unnamed: R35.2, R37.1, U3.7
unnamed: R40.2, R41.1, U4.14
unnamed: R44.2, RV4.2
unnamed: J3.TN, SW1.2 (B)
unnamed: R9.2, SW1.3 (C)
unnamed: RV1.1, SW2.2 (B)
unnamed: C33.1, R8.1, R11.2, SW2.3 (C), U1.9 (-)
unnamed: J5.TN, SW3.2 (B)
unnamed: R19.2, SW3.3 (C)
unnamed: RV2.1, SW4.2 (B)
unnamed: C34.1, R17.2, R18.1, R21.2, SW4.3 (C), U2.9 (-)
unnamed: J7.TN, SW5.2 (B)
unnamed: R29.2, SW5.3 (C)
unnamed: RV3.1, SW6.2 (B)
unnamed: C35.1, R27.2, R28.1, R31.2, SW6.3 (C), U3.9 (-)
unnamed: J9.TN, SW7.2 (B)
unnamed: R39.2, SW7.3 (C)
unnamed: RV4.1, SW8.2 (B)
unnamed: C36.1, R37.2, R38.1, R41.2, SW8.3 (C), U4.9 (-)
unnamed: J2.T, R8.2, R12.2, U1.3 (+)
unnamed: R15.1, R16.2, U1.6 (-)
unnamed: R10.1, RV1.3, U1.13 (-)
unnamed: J4.T, R18.2, R22.2, U2.3 (+)
unnamed: R25.1, R26.2, U2.6 (-)
unnamed: R20.1, RV2.3, U2.13 (-)
unnamed: J6.T, R28.2, R32.2, U3.3 (+)
unnamed: R35.1, R36.2, U3.6 (-)
unnamed: R30.1, RV3.3, U3.13 (-)
unnamed: J8.T, R38.2, R42.2, U4.3 (+)
unnamed: R40.1, RV4.3, U4.13 (-)
VREF_+10: R9.1, R19.1, R29.1, R39.1, SW1.1 (A), SW3.1 (A), SW5.1 (A), SW7.1 (A); also elsewhere on the board

Notes on the sheet:
+:Green -:Red
+:Green -:Red 1→2(Anode→Cathode)順方向で赤点灯なので +で緑にしたい場合、足が短いカソード側をオペアンプ1番ピンに繋ぐ

Parts:
C1, C6: 22uF; C_0805_2012Metric; LCSC C45783
C2, C3, C4, C5, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32: 100nF; C_0603_1608Metric; LCSC C14663
D1, D2: 1N5819WS; D_SOD-323; LCSC C64886
J1: POWER; PinHeader_2x05_2.54mm_Europower
R1: 1K; R_0603_1608Metric; LCSC C21190
R2, R5, R6: 100K; R_0603_1608Metric; LCSC C25803
R3: 200K; R_0603_1608Metric; LCSC C25811
R4, R7: 10K; R_0603_1608Metric; LCSC C25804
TP1: +5V_TP; TestPoint_Pad_1.0x1.0mm
TP2: -5V_TP; TestPoint_Pad_1.0x1.0mm
TP3: +10V_TP; TestPoint_Pad_1.0x1.0mm
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12: TL074CDR; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C12594
U13, U14: TL072CDT; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C6961
U15: CJ431; SOT-23; LCSC C3113

Connections:
+12V: C1.1, C2.1, C3.1, C4.1, C5.1, C11.1, C12.1, C13.1, C14.1, C19.1, C20.1, C21.1, C22.1, C27.1, C28.1, D1.1 (K), R1.1, U1.4 (V+), U2.4 (V+), U3.4 (V+), U4.4 (V+), U5.4 (V+), U6.4 (V+), U7.4 (V+), U8.4 (V+), U9.4 (V+), U10.4 (V+), U11.4 (V+), U12.4 (V+), U13.8 (V+), U14.8 (V+); also elsewhere on the board
-12V: C6.2, C7.2, C8.2, C9.2, C10.2, C15.2, C16.2, C17.2, C18.2, C23.2, C24.2, C25.2, C26.2, C29.2, C30.2, D2.2 (A), U1.11 (V-), U2.11 (V-), U3.11 (V-), U4.11 (V-), U5.11 (V-), U6.11 (V-), U7.11 (V-), U8.11 (V-), U9.11 (V-), U10.11 (V-), U11.11 (V-), U12.11 (V-), U13.4 (V-), U14.4 (V-); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, C17.1, C18.1, C19.2, C20.2, C21.2, C22.2, C23.1, C24.1, C25.1, C26.1, C27.2, C28.2, C29.1, C30.1, C31.2, C32.2, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, R7.2, U13.3 (+), U13.5 (+), U15.3 (A); also elsewhere on the board
unnamed: D1.2 (A), J1.1, J1.2
unnamed: D2.1 (K), J1.9, J1.10
unnamed: R2.1, R5.2, U13.2 (-)
unnamed: R3.1, R6.2, U13.6 (-)
unnamed: R4.2, R7.1, U15.1 (REF)
VREF_+5: C31.1, C32.1, R1.2, R4.1, R5.1, TP1.1 (1_1), U15.2 (K); also elsewhere on the board
VREF_+10: R3.2, TP3.1 (1_1), U13.7; also elsewhere on the board
VREF_-5: R2.2, R6.1, TP2.1 (1_1), U13.1; also elsewhere on the board

Parts:
C39: 22pF; C_0603_1608Metric; LCSC C1653
C40: 0.1uF/16V; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C41, C42: 10u; CP_EIA-3216-18_Kemet-A; LCSC C7171
C43: 0.01uF/16V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C44: 10n; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C45: 100p; C_0402_1005Metric; LCSC C1546
D20, D22: 1N4148WS; D_SOD-323; LCSC C2128
D21: LED_Dual_Bidirectional; LED_D3.0mm
J30: Jumper; PinHeader_1x03_P2.54mm_Vertical
J31: Kinks_OUT_Noise; AudioJack_PJ301M-12
J32: Kinks_OUT_S&H; AudioJack_PJ301M-12
J33: Kinks_S&H_IN; AudioJack_PJ301M-12
J34: Kinks_S&H_TRIG; AudioJack_PJ301M-12
Q1, Q2: 2SC1815; SOT-23; LCSC C20069143
Q3: MMBFJ310; SOT-23; LCSC C33416
R89: 470K; R_0402_1005Metric; LCSC C25790
R90: 4.7K; R_0402_1005Metric; LCSC C25900
R91: 200K; R_0603_1608Metric; LCSC C25811
R92, R103, R104: 100K; R_0402_1005Metric; LCSC C25741
R93, R96, R97: 100R; R_0402_1005Metric; LCSC C25076
R94: 2.2K; R_0603_1608Metric; LCSC C4190
R95: 2K; R_0603_1608Metric; LCSC C22975
R98, R99, R100: 1M; R_0402_1005Metric; LCSC C26083
R101, R105: 10K; R_0402_1005Metric; LCSC C25744
R102: 1K; R_0402_1005Metric; LCSC C11702
U7, U11: TL074CDR; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C12594
U14: TL072CDT; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C6961

Connections:
+12V: R89.1, R90.1, R100.1; also elsewhere on the board
GND: C42.2, C44.2, D22.2 (A), J31.S, J32.S, J33.S, J34.S, J34.TN, Q2.2 (E), R98.2, R102.1, R103.2, R104.2, R105.2, U11.10 (+), U14.3 (+), U14.5 (+); also elsewhere on the board
NOISE: J30.2, J31.T, J33.TN
unnamed: C39.2, R91.2, R93.1, R95.1, U14.1
unnamed: C40.2, R92.1
unnamed: C41.2, C42.1
unnamed: C43.1, R95.2
unnamed: C45.1, J34.T, R103.1
unnamed: D20.2 (A), Q3.3 (G), R99.2
unnamed: D20.1 (K), U11.14
unnamed: D21.2 (AK), U7.1
unnamed: D21.1 (KA), R102.2, U7.2 (-)
unnamed: C45.2, D22.1 (K), R101.1
unnamed: J30.1, R93.2
unnamed: J30.3, R96.2
unnamed: J32.T, R97.2
unnamed: Q1.1 (B), Q2.1 (B)
unnamed: C41.1, Q1.2 (E), R89.2
unnamed: C40.1, Q2.3 (C), R90.2
unnamed: Q3.1 (D), R99.1, U11.1, U11.2 (-)
unnamed: C44.1, Q3.2 (S), U11.5 (+)
unnamed: R94.2, R96.1, U14.7
unnamed: J33.T, R98.1, U11.3 (+)
unnamed: R97.1, U7.3 (+), U11.6 (-), U11.7
unnamed: U11.8, U11.9 (-)
unnamed: R101.2, R104.1, U11.12 (+)
unnamed: R100.2, R105.1, U11.13 (-)
unnamed: C39.1, R91.1, R92.2, U14.2 (-)
unnamed: C43.2, R94.1, U14.6 (-)

Notes on the sheet:
Flilm cap
ECHU1C104JX5
ECHU1C103JX5
+:Green -:Red
Tantalum 5uF

Parts:
D13, D14, D15, D16, D17, D18: 1N4148WS; D_SOD-323; LCSC C2128
D19: LED_Dual_Bidirectional; LED_D3.0mm
J26: Kinks_OUT_MAX; AudioJack_PJ301M-12
J27: Kinks_IN_A; AudioJack_PJ301M-12
J28: Kinks_IN_B; AudioJack_PJ301M-12
J29: Kinks_OUT_MIN; AudioJack_PJ301M-12
R80, R82, R83, R85: 220K; R_0402_1005Metric; LCSC C25767
R81, R84: 100R; R_0402_1005Metric; LCSC C25076
R86, R87: 1M; R_0402_1005Metric; LCSC C26083
R88: 1K; R_0402_1005Metric; LCSC C11702
U6, U7: TL074CDR; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C12594

Connections:
+12V: R83.1, R85.2; also elsewhere on the board
-12V: R80.1, R82.2; also elsewhere on the board
GND: J26.S, J27.S, J27.TN, J28.S, J28.TN, J29.S, R88.1; also elsewhere on the board
unnamed: D13.2 (A), R81.1, U7.8
unnamed: D13.1 (K), R80.2, U7.9 (-)
unnamed: D14.2 (A), D17.1 (K), J27.T, R86.1
unnamed: D14.1 (K), D15.1 (K), R82.1, U7.10 (+)
unnamed: D15.2 (A), D18.1 (K), J28.T, R87.1
unnamed: D16.2 (A), R83.2, U6.6 (-)
unnamed: D16.1 (K), R84.1, U6.7
unnamed: D17.2 (A), D18.2 (A), R85.1, U6.5 (+)
unnamed: D19.2 (AK), U7.14
unnamed: D19.1 (KA), R88.2, U7.13 (-)
unnamed: J26.T, R81.2
unnamed: J29.T, R84.2
unnamed: R86.2, R87.2, U7.12 (+)

Notes on the sheet:
+:Green -:Red

Parts:
C37, C38: 10p; C_0402_1005Metric; LCSC C32949
D7, D8, D9: LED_Dual_Bidirectional; LED_D3.0mm
J10: Links_1to3_OUT1; AudioJack_PJ301M-12
J11: Links_1to3_IN; AudioJack_PJ301M-12
J12: Links_3to1_IN1; AudioJack_PJ301M-12
J13: Links_1to3_OUT2; AudioJack_PJ301M-12
J14: Links_3to1_IN2; AudioJack_PJ301M-12
J15: Links_3to1_OUT; AudioJack_PJ301M-12
J16: Links_1to3_OUT3; AudioJack_PJ301M-12
J17: Links_3to1_IN3; AudioJack_PJ301M-12
J18: Links_2to2_IN1; AudioJack_PJ301M-12
J19: Links_2to2_IN2; AudioJack_PJ301M-12
J20: Links_2to2_OUT1; AudioJack_PJ301M-12
J21: Links_2to2_OUT2; AudioJack_PJ301M-12
R45, R48, R53, R54, R63, R64: 100R; R_0402_1005Metric; LCSC C25076
R46, R50, R51, R52, R55, R58, R59, R60, R61, R62: 100K; R_0402_1005Metric; LCSC C25741
R47: 10M; R_0402_1005Metric; LCSC C26082
R49: 33K; R_0402_1005Metric; LCSC C25779
R56, R57, R65: 1K; R_0402_1005Metric; LCSC C11702
U5, U6, U9: TL074CDR; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C12594

Connections:
GND: J10.S, J11.S, J11.TN, J12.S, J12.TN, J13.S, J14.S, J14.TN, J15.S, J16.S, J17.S, J17.TN, J18.S, J18.TN, J19.S, J19.TN, J20.S, J21.S, R47.2, R56.1, R57.1, R65.1, U5.5 (+), U6.10 (+), U9.3 (+), U9.5 (+); also elsewhere on the board
unnamed: D7.2 (AK), U6.14
unnamed: D7.1 (KA), R56.2, U6.13 (-)
unnamed: D8.2 (AK), U5.14
unnamed: D8.1 (KA), R57.2, U5.13 (-)
unnamed: D9.2 (AK), U5.1
unnamed: D9.1 (KA), R65.2, U5.2 (-)
unnamed: J10.T, R45.2
unnamed: J12.T, R46.1
unnamed: J13.T, R48.2
unnamed: J14.T, R51.1
unnamed: J15.T, R53.2
unnamed: J16.T, R54.2
unnamed: J17.T, R55.1
unnamed: J18.T, R58.1
unnamed: J19.T, R61.1
unnamed: J20.T, R63.2
unnamed: J21.T, R64.2
unnamed: R49.2, R52.1, U6.8
unnamed: R59.2, R62.1, U9.1
unnamed: C38.2, R60.2, R63.1, R64.1, U5.3 (+), U9.7
unnamed: C37.1, R50.1, R52.2, U5.6 (-)
unnamed: J11.T, R47.1, U5.10 (+), U5.12 (+), U9.10 (+), U9.12 (+)
unnamed: R45.1, U5.8, U5.9 (-)
unnamed: R46.2, R49.1, R51.2, R55.2, U6.9 (-)
unnamed: C37.2, R50.2, R53.1, U5.7, U6.12 (+)
unnamed: R58.2, R59.1, R61.2, U9.2 (-)
unnamed: C38.1, R60.1, R62.2, U9.6 (-)
unnamed: R54.1, U9.8, U9.9 (-)
unnamed: R48.1, U9.13 (-), U9.14

Notes on the sheet:
+:Green -:Red
2:2
3:1
1:3
