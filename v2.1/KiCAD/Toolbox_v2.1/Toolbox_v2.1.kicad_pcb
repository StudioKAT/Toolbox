# Repository StudioKAT/Toolbox (continued)

## KiCad design v1.0/KiCAD/Toolbox_v1.0/Toolbox_v1.0.kicad_pcb (continued)

Parts:
C39, C40: 10p; C_0402_1005Metric; LCSC C32949
D7, D8, D9: LED_Dual_Bidirectional; LED_D3.0mm
J10: Links_1to3_OUT1; AudioJack_PJ301M-12
J11: Links_1to3_IN; AudioJack_PJ301M-12
J12: Links_1to3_OUT2; AudioJack_PJ301M-12
J13: Links_1to3_OUT3; AudioJack_PJ301M-12
J14: Links_2to2_IN1; AudioJack_PJ301M-12
J15: Links_2to2_IN2; AudioJack_PJ301M-12
J16: Links_2to2_OUT1; AudioJack_PJ301M-12
J17: Links_2to2_OUT2; AudioJack_PJ301M-12
J18: Links_3to1_IN1; AudioJack_PJ301M-12
J19: Links_3to1_IN2; AudioJack_PJ301M-12
J20: Links_3to1_OUT; AudioJack_PJ301M-12
J21: Links_3to1_IN3; AudioJack_PJ301M-12
R47, R49, R50, R57, R58, R65: 100R; R_0402_1005Metric; LCSC C25076
R48: 10M; R_0402_1005Metric; LCSC C26082
R51, R59, R67: 1K; R_0402_1005Metric; LCSC C11702
R52, R53, R54, R55, R56, R60, R62, R63, R64, R66: 100K; R_0402_1005Metric; LCSC C25741
R61: 33K; R_0402_1005Metric; LCSC C25779
U5, U6, U9: TL074; TSSOP-14_4.4x5mm_P0.65mm; LCSC C4370424

Connections:
GND: J10.S, J11.S, J11.TN, J12.S, J13.S, J14.S, J14.TN, J15.S, J15.TN, J16.S, J17.S, J18.S, J18.TN, J19.S, J19.TN, J20.S, J21.S, J21.TN, R48.2, R51.1, R59.1, R67.1, U5.5 (+), U6.10 (+), U9.3 (+), U9.5 (+); also elsewhere on the board
unnamed: D7.2 (AK), U5.14
unnamed: D7.1 (KA), R51.2, U5.13 (-)
unnamed: D8.2 (AK), U5.1
unnamed: D8.1 (KA), R59.2, U5.2 (-)
unnamed: D9.2 (AK), U6.14
unnamed: D9.1 (KA), R67.2, U6.13 (-)
unnamed: J10.T, R47.2
unnamed: J12.T, R49.2
unnamed: J13.T, R50.2
unnamed: J14.T, R52.1
unnamed: J15.T, R55.1
unnamed: J16.T, R57.2
unnamed: J17.T, R58.2
unnamed: J18.T, R60.1
unnamed: J19.T, R63.1
unnamed: J20.T, R65.2
unnamed: J21.T, R66.1
unnamed: R53.2, R56.1, U9.1
unnamed: R61.2, R64.1, U6.8
unnamed: C39.2, R54.2, R57.1, R58.1, U5.3 (+), U9.7
unnamed: C40.1, R62.1, R64.2, U5.6 (-)
unnamed: J11.T, R48.1, U5.10 (+), U5.12 (+), U9.10 (+), U9.12 (+)
unnamed: R47.1, U5.8, U5.9 (-)
unnamed: R60.2, R61.1, R63.2, R66.2, U6.9 (-)
unnamed: C40.2, R62.2, R65.1, U5.7, U6.12 (+)
unnamed: R52.2, R53.1, R55.2, U9.2 (-)
unnamed: C39.1, R54.1, R56.2, U9.6 (-)
unnamed: R50.1, U9.8, U9.9 (-)
unnamed: R49.1, U9.13 (-), U9.14

Notes on the sheet:
+:Green -:Red

Parts:
D23: LED_Dual_Bidirectional; LED_D3.0mm
J34: OUT_+10V; AudioJack_PJ301M-12
J35: IN_±5V; AudioJack_PJ301M-12
J36: IN_+10V; AudioJack_PJ301M-12
J37: OUT_±5V; AudioJack_PJ301M-12
R105, R106, R108, R109, R110, R111, R112, R113, R114, R116: 100K; R_0402_1005Metric; LCSC C25741
R107, R115: 100R; R_0402_1005Metric; LCSC C25076
R117: 1K; R_0402_1005Metric; LCSC C11702
U7, U8, U12: TL074; TSSOP-14_4.4x5mm_P0.65mm; LCSC C4370424

Connections:
GND: J34.S, J35.S, J35.TN, J36.S, J37.S, R117.1, U7.5 (+), U8.10 (+), U12.10 (+), U12.12 (+); also elsewhere on the board
unnamed: D23.2 (AK), U8.14
unnamed: D23.1 (KA), R117.2, U8.13 (-)
unnamed: J34.T, R107.2
unnamed: J36.T, R113.1
unnamed: J36.TN, R106.2, R107.1, U7.7
unnamed: J37.T, R115.2
unnamed: R105.2, R109.1, U8.8
unnamed: R111.2, R114.1, U12.14
unnamed: R112.2, R115.1, U12.8
unnamed: R106.1, R109.2, R110.2, U7.6 (-)
unnamed: R105.1, R108.2, U8.9 (-)
unnamed: J35.T, R108.1, U8.12 (+)
unnamed: R112.1, R114.2, R116.2, U12.9 (-)
unnamed: R111.1, R113.2, U12.13 (-)
VREF_+5: R116.1; also elsewhere on the board
VREF_-5: R110.1; also elsewhere on the board

Notes on the sheet:
0~+10V
rev2でOUT側に変更予定
-10V~0V
±5V
+:Green -:Red
∓5V

Parts:
D10: LED_Dual_Bidirectional; LED_D3.0mm
D11, D12: 1N4148WS; D_SOD-323; LCSC C2128
J22: Kinks_IN; AudioJack_PJ301M-12
J23: Kinks_OUT_INV; AudioJack_PJ301M-12
J24: Kinks_OUT_HW; AudioJack_PJ301M-12
J25: Kinks_OUT_FW; AudioJack_PJ301M-12
R68, R69, R73, R74, R79, R80: 200K; R_0402_1005Metric; LCSC C25764
R70, R76, R81: 100R; R_0402_1005Metric; LCSC C25076
R71: 1K; R_0402_1005Metric; LCSC C11702
R72, R75, R77, R78: 100K; R_0402_1005Metric; LCSC C25741
U6, U10: TL074; TSSOP-14_4.4x5mm_P0.65mm; LCSC C4370424

Connections:
GND: J22.S, J22.TN, J23.S, J24.S, J25.S, R71.1, U10.3 (+), U10.5 (+), U10.10 (+), U10.12 (+); also elsewhere on the board
unnamed: D10.2 (AK), U6.1
unnamed: D10.1 (KA), R71.2, U6.2 (-)
unnamed: D11.2 (A), D12.1 (K), U10.7
unnamed: D11.1 (K), R72.1, R74.2, U10.6 (-)
unnamed: D12.2 (A), R72.2, R75.1, R77.1, R78.1
unnamed: J23.T, R70.2
unnamed: J24.T, R76.2
unnamed: J25.T, R81.2
unnamed: R68.2, R70.1, U10.1
unnamed: R73.2, R76.1, U10.8
unnamed: R79.2, R81.1, U10.14
unnamed: J22.T, R69.1, R74.1, R80.1, U6.3 (+)
unnamed: R68.1, R69.2, U10.2 (-)
unnamed: R73.1, R75.2, U10.9 (-)
unnamed: R77.2, R78.2, R79.1, R80.2, U10.13 (-)

Notes on the sheet:
+:Green -:Red

Schematic: Voltage_Doubler.kicad_sch, Voltage Doubler

Parts:
C46: 10p; C_0402_1005Metric; LCSC C32949
D24: LED_Dual_Bidirectional; LED_D3.0mm
J38: IN; AudioJack_PJ301M-12
J39: OUT_x1.25; AudioJack_PJ301M-12
J40: OUT_x1.6; AudioJack_PJ301M-12
J41: OUT_x2; AudioJack_PJ301M-12
R118, R120, R126: 100K; R_0402_1005Metric; LCSC C25741
R119: 150K; R_0402_1005Metric; LCSC C25755
R121, R123: 120K; R_0402_1005Metric; LCSC C25750
R122, R125, R128: 100R; R_0402_1005Metric; LCSC C25076
R124: 75K; R_0402_1005Metric; LCSC C25798
R127: 49.9K; R_0402_1005Metric; LCSC C25897
R129: 1K; R_0402_1005Metric; LCSC C11702
U4, U8, U12: TL074; TSSOP-14_4.4x5mm_P0.65mm; LCSC C4370424

Connections:
GND: J38.S, J38.TN, J39.S, J40.S, J41.S, R129.1, U8.3 (+), U8.5 (+), U12.3 (+), U12.5 (+); also elsewhere on the board
unnamed: C46.2, R118.2, R121.1, R124.1, R127.1, U8.1
unnamed: D24.2 (AK), U4.7
unnamed: D24.1 (KA), R129.2, U4.6 (-)
unnamed: J39.T, R122.2
unnamed: J40.T, R125.2
unnamed: J41.T, R128.2
unnamed: R119.2, R122.1, U8.7
unnamed: R123.2, R125.1, U12.1
unnamed: R126.2, R128.1, U12.7
unnamed: J38.T, R120.1, U4.5 (+)
unnamed: C46.1, R118.1, R120.2, U8.2 (-)
unnamed: R119.1, R121.2, U8.6 (-)
unnamed: R123.1, R124.2, U12.2 (-)
unnamed: R126.1, R127.2, U12.6 (-)

Notes on the sheet:
8V to 10V
5V to 10V
+:Green -:Red
5V to 8V

Board: 2 copper layers, 170.4 x 128.5 mm, 338 parts (207 on the bottom side), 174 nets.

## Commit log

2025-04-24 マニュアル追加
2025-04-30 消費電流を実測値に変更
2025-05-22 フォルダ構成変更
2025-05-23 KiCADプロジェクト追加
2025-05-28 画像差し替え
2025-06-08 ディレクトリ構成変更
2025-07-31 v2.1 Update
2026-05-06 R91 定数変更 240K→200K
